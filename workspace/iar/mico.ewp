# IAR project mico.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F205ZG ST STM32F205ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pe144
  ICCARM.CCIncludePath2: ..\..\include; ..\..\arch\arm\include; ..\..\drivers
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: mico.bin
  ILINK.IlinkOutputFile: mico.out
  ILINK.IlinkIcfFile: mico.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group arch/kernel
    ../../arch/arm/kernel/: devicetree.c setup.c
  group arch/mach-emw3162
    ../../arch/arm/mach-emw3162/: head.s irq.c soc-emw3162.c
  group arch/mach-emw3165
    ../../arch/arm/mach-emw3165/: soc-emw3165.c
  group drivers/base
    ../../drivers/base/: bus.c core.c dd.c platform.c
  group drivers/clock
    ../../drivers/clock/: stm32_clock.c
  group drivers/gpio
    ../../drivers/gpio/: stm32_gpio.c
  group drivers/sdt
    ../../drivers/sdt/: sdt.c
  group drivers/serial
    ../../drivers/serial/: stm32_uart.c
  group init
    ../../init/: main.c
  group lib
    ../../lib/: klist.c
  group mico
    ../../mico/: mico_port.c mxchipWNet_cm3_sdio.a
