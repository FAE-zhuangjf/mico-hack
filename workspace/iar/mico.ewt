<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>arch</name>
    <group>
      <name>kernel</name>
      <file>
        <name>$PROJ_DIR$\..\..\arch\arm\kernel\devicetree.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\arch\arm\kernel\setup.c</name>
      </file>
    </group>
    <group>
      <name>mach-emw3162</name>
      <file>
        <name>$PROJ_DIR$\..\..\arch\arm\mach-emw3162\head.s</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\arch\arm\mach-emw3162\irq.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\arch\arm\mach-emw3162\soc-emw3162.c</name>
      </file>
    </group>
    <group>
      <name>mach-emw3165</name>
      <file>
        <name>$PROJ_DIR$\..\..\arch\arm\mach-emw3165\soc-emw3165.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>drivers</name>
    <group>
      <name>base</name>
      <file>
        <name>$PROJ_DIR$\..\..\drivers\base\bus.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\drivers\base\core.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\drivers\base\dd.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\drivers\base\platform.c</name>
      </file>
    </group>
    <group>
      <name>clock</name>
      <file>
        <name>$PROJ_DIR$\..\..\drivers\clock\stm32_clock.c</name>
      </file>
    </group>
    <group>
      <name>gpio</name>
      <file>
        <name>$PROJ_DIR$\..\..\drivers\gpio\stm32_gpio.c</name>
      </file>
    </group>
    <group>
      <name>sdt</name>
      <file>
        <name>$PROJ_DIR$\..\..\drivers\sdt\sdt.c</name>
      </file>
    </group>
    <group>
      <name>serial</name>
      <file>
        <name>$PROJ_DIR$\..\..\drivers\serial\stm32_uart.c</name>
        <configuration>
          <name>Debug</name>
        </configuration>
      </file>
    </group>
  </group>
  <group>
    <name>init</name>
    <file>
      <name>$PROJ_DIR$\..\..\init\main.c</name>
    </file>
  </group>
  <group>
    <name>lib</name>
    <file>
      <name>$PROJ_DIR$\..\..\lib\klist.c</name>
    </file>
  </group>
  <group>
    <name>mico</name>
    <file>
      <name>$PROJ_DIR$\..\..\mico\mico_port.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\mico\mxchipWNet_cm3_sdio.a</name>
    </file>
  </group>
</project>


